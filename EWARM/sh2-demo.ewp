# IAR project sh2-demo.ewp, settings and files
configuration bno08x-uart (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../main; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../app; ../sh2; ..\dfu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\main
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: sh2-demo.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration bno08x-i2c (ARM, debug)
  as the first configuration, except:
configuration bno08x-spi (ARM, debug)
  as the first configuration, except:
configuration fsp20x-uart (ARM, debug)
  as the first configuration, except:
configuration fsp201-i2c (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
configuration fsp20x-uart-cal (ARM, debug)
  as the first configuration, except:
configuration fsp201-i2c-cal (ARM, debug)
  as the first configuration, except:
configuration demo-rvc (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ../main; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../app; ../sh2; ../rvc; ../dfu
  group Application/App
    ../app/: bno08x_i2c_hal.c bno08x_uart_hal.c button.c cal_app.c console.c dbg.c demo_app.c demo_rvc.c fsp201_i2c_hal.c fsp20x_uart_hal.c i2c_hal.c spi_hal.c uart_hal.c usart.c
    ../sh2/: euler.c
  group Application/DFU
    ../dfu/: dfu_bno.c dfu_fsp200.c firmware-bno.c firmware-fsp.c
  group Application/Main
    ../main/: main.c startup_stm32f411xe.s stm32f4xx_hal_timebase_TIM.c system_stm32f4xx.c
  group Application/RVC Driver
    ../rvc/: rvc.c rvc_hal.c
  group Application/SH2 Driver
    ../sh2/: sh2.c sh2_SensorValue.c sh2_util.c shtp.c
  group STM32F4xx_HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
